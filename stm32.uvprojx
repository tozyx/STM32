# Keil uVision project stm32.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED
  c flags: Optim=2 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: .\START;.\LIBRARY;.\USER;.\SYSTEM;.\HARDWARE;.\SYSTEM\sys;.\HARDWARE\OLED;.\HARDWARE\DHT11;.\HARDWARE\BlueTooth;.\HARDWARE\Funtion;.\U8G2
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group START
    ./START/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h startup_stm32f10x_md.s
  group Library
    ./LIBRARY/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group System
    ./SYSTEM/: Delay.c Delay.h Timer.c Timer.h
    ./SYSTEM/sys/: sys.c sys.h
  group Hardware
    ./HARDWARE/: OLED.c OLED.h OLED_Font.h DH11.c DH11.h
    ./HARDWARE/BlueTooth/: bsp_usart.c bsp_usart.h
    ./HARDWARE/Funtion/: function.c function.h
  group USER
    ./USER/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group U8G2
    ./u8g2/: u8g2.h u8g2_arc.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8.h u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_ssd1306_128x64_noname.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c pic.h pic.c pic_pic.h Gif.h
